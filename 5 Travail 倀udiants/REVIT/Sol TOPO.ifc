Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: E:\Numérisation\Projet3.ifc
Time: 2018-01-19T14:47:16

# IfcSite, Covadis : TN
Description: Terrain Naturel; RefElevation: 0 m
Propriétés du Site - Z max: 26.1 m; Surface 3D: 1458.17 m2; Z min: 19.69 m; Surface 2D: 1420.99 m2

# IfcBuilding
Informations de création - Prénom de l'auteur: Géomètre; Nom de l'auteur: Bac pro; Entreprise: Lycée Laplace; Date: 2018-01-19 14:47:16
